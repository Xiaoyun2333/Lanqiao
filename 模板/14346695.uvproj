# Keil uVision project 14346695.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 14346695 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 14346695.c iic.c base.c uart.c onewire.c ds1302.c iic.h uart.h onewire.h base.h ds1302.h
